require gcc-externc.inc
