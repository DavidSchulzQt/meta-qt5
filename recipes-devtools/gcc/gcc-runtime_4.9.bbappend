require gcc-externc.inc

FILES_libstdc++-dev_append_mingw32 = " ${bindir}/libstdc++*.dll"
FILES_libstdc++-dev_append_mingw32 = " ${libdir}/libstdc++*.dll"
